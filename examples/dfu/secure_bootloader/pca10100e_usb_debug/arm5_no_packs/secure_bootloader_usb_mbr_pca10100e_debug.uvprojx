# Keil uVision project secure_bootloader_usb_mbr_pca10100e_debug.uvprojx, settings and files
target nrf52820_xxaa_debug (ARM-ADS)
  device: nRF52820_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") CLOCK(64000000) ELITTLE
  output: nrf52820_xxaa_debug +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10100 CONFIG_GPIO_AS_PINRESET DEBUG_NRF DEVELOP_IN_NRF52833 FLOAT_ABI_SOFT MBR_PRESENT NRF52820_XXAA NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 NRF_DFU_DEBUG_VERSION NRF_DFU_SETTINGS_VERSION=2 SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  c misc: --reduce_paths
  c include: ..\..\config;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\components\libraries\bootloader\serial_dfu;..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\components\libraries\crypto\backend\optiga;..\..\..\..\..\components\libraries\delay;..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\components\libraries\log;..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\components\libraries\queue;..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\components\libraries\slip;..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\softdevice\mbr\headers;..\..;..\..\..\..\..\external\fprintf;..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\external\nano-pb;..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\external\segger_rtt;..\..\..\..\..\external\utf_converter;..\..\..\..\..\integration\nrfx;..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\modules\nrfx;..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\modules\nrfx\hal;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10100,-DCONFIG_GPIO_AS_PINRESET,-DDEBUG_NRF,-DDEVELOP_IN_NRF52833,-DFLOAT_ABI_SOFT,-DMBR_PRESENT,-DNRF52820_XXAA,-DNRFX_COREDEP_DELAY_US_LOOP_CYCLES=3,-DNRF_DFU_DEBUG_VERSION,-DNRF_DFU_SETTINGS_VERSION=2,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-D__HEAP_SIZE=0,-DuECC_ENABLE_VLI_API=0,-DuECC_OPTIMIZATION_LEVEL=3,-DuECC_SQUARE_FUNC=0,-DuECC_SUPPORT_COMPRESSED_POINT=0,-DuECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x2c000 size 0x12000
  memory RVCT9: RAM 0x20000008 size 0x7ff8
  link misc: --diag_suppress 6330
  group Application
    ../../../: dfu_public_key.c
    ../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../components/boards/: boards.c
  group UTF8/UTF16 converter
    ../../../../../external/utf_converter/: utf.c
  group nRF_Bootloader
    ../../../../../components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group nRF_Crypto
    ../../../../../components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend Oberon
    ../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend nRF sw
    ../../../../../components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Crypto backend uECC
    ../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_DFU
    ../../../../../components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
  group nRF_Drivers
    ../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_uart.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_power.c nrfx_systick.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c
    ../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../../../../../components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../../../../components/libraries/crc32/: crc32.c
    ../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../components/libraries/sha256/: sha256.c
    ../../../../../components/libraries/slip/: slip.c
  group nRF_Log
    ../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../../../../../external/nrf_oberon/lib/cortex-m4/soft-float/short-wchar/: oberon_3.0.8.lib
  group nRF_Segger_RTT
    ../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_Serial_DFU
    ../../../../../components/libraries/bootloader/serial_dfu/: nrf_dfu_serial.c
  group nRF_USB_DFU
    ../../../../../components/libraries/bootloader/serial_dfu/: nrf_dfu_serial_usb.c
  group nRF_micro-ecc
    ../../../../../external/micro-ecc/nrf52nf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../../../../../external/nano-pb/: pb_common.c pb_decode.c
target flash_mbr (ARM-ADS)
  device: nRF52820_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: as above
  output: mbr_nrf52_2.4.1_mbr.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: as above
  c misc: --reduce_paths
  c include: as above
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x2c000 size 0x12000
  memory RVCT9: RAM 0x20000008 size 0x7ff8
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, Device:Startup 8.40.3
